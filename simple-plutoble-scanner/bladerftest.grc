options:
  parameters:
    generate_options: qt_gui
    id: bladerftest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: tune
  id: variable
  parameters:
    value: 2.40e9
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2048.0'
    vector_input: 'True'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tune
    fftsize: '32768'
    type: complex
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: samp_rate/2
    center_freq: tune
    dev_args: buflen=32768,buffers=128
    samp_rate: samp_rate
    type: sc16
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
