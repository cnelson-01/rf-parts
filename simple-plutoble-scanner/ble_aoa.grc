options:
  parameters:
    description: 'BLE Angle-of-Arrival capture on a bladeRF 2.0 micro: two phase-coherent RX channels (RX0 reference + RX1) both tuned to ch37 (2.402 GHz). RX0 drives the BLE decode chain; RX0*conj(RX1) feeds the AoA decoder, which logs phase_rad + aoa_deg to the shared sqlite db. Note: this bladeRF cannot run 2-channel RX and TX at once (bladerf_sync_config -3), so calibration uses an external common reference at broadside rather than an on-board TX tone -- see run_aoa.sh / README for the procedure.'
    generate_options: qt_gui
    id: ble_aoa
    output_language: python
    title: BLE AoA capture (bladeRF ch37, 2x RX)
  states: {}

blocks:
- name: db_path
  id: variable
  parameters:
    value: '"ble_scan.db"'
  states: {}
- name: aoa_samp_rate
  id: variable
  parameters:
    comment: 4 MSPS = 4 samples/symbol for the BLE 1 Msym/s GFSK
    value: '4000000'
  states: {}
- name: aoa_rf_bw
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: aoa_center
  id: variable
  parameters:
    comment: ch37 = 2402 MHz (zero-IF). See note on DC offset below.
    value: 2.402e9
  states: {}
- name: antenna_spacing_m
  id: variable
  parameters:
    comment: array element spacing; ~lambda/2 at 2.402 GHz (lambda=0.1248 m)
    value: '0.0625'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: cal_on
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: Press while a strong common reference sits at broadside (0°) to measure phi_cal; release to resume AoA decoding. Persisted to aoa_cal.json.
    value: '0'
    type: int
    label: CAPTURE phi_cal  (reference at 0°, then release)
    initPressed: 'False'
    pressed: '1'
    released: '0'
    pressBackgroundColor: orange
    pressFontColor: black
  states: {}
- name: aoa_source
  id: soapy_source
  parameters:
    comment: 'nchan=2, both tuned to aoa_center. dc_removal MUST be False: this bladeRF reports hasDCOffsetMode=False and gr-soapy throws on a True request. Disabling auto-DC is also correct for AoA — per-channel automatic DC removal could differ and skew the inter-channel phase.'
    nchan: '2'
    devname: bladerf
    type: fc32
    samp_rate: aoa_samp_rate
    center_freq0: aoa_center
    overall_gain0: rx_gain
    bw0: aoa_rf_bw
    dc_removal0: 'False'
    center_freq1: aoa_center
    overall_gain1: rx_gain
    ant1: RX
    bw1: aoa_rf_bw
    dc_removal1: 'False'
    agc1: 'False'
  states: {}
- name: ref_gfsk
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: ref_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: ref_keep
  id: blocks_keep_one_in_n
  parameters:
    comment: 4 MSPS -> 1 MSPS
    n: '4'
    type: float
  states: {}
- name: cross
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: arg = phi0 - phi1; carrier cancels
  states: {}
- name: cross_keep
  id: blocks_keep_one_in_n
  parameters:
    comment: 4 MSPS -> 1 MSPS, aligned with power
    n: '4'
    type: complex
  states: {}
- name: cross_arg
  id: blocks_complex_to_arg
  parameters:
    comment: live inter-channel phase (rad)
  states: {}
- name: aoa_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Shim: thin GRC wrapper around ble_aoa_decoder.blk."""
      import os, sys
      _HERE = os.path.expanduser('~/Software/rf-parts/simple-plutoble-scanner')
      if _HERE not in sys.path:
          sys.path.insert(0, _HERE)
      from ble_aoa_decoder import blk as _Parent


      class blk(_Parent):
          def __init__(self, channel_index=37, sdr_name="bladerf_aoa",
                       db_path="ble_scan.db", center_freq=2.402e9,
                       antenna_spacing_m=0.0625, cal_active=False,
                       cal_file="aoa_cal.json", invert=False, debug=False):
              _Parent.__init__(self, channel_index=channel_index,
                               sdr_name=sdr_name, db_path=db_path,
                               center_freq=center_freq,
                               antenna_spacing_m=antenna_spacing_m,
                               cal_active=cal_active, cal_file=cal_file,
                               invert=invert, debug=debug)
    channel_index: '37'
    sdr_name: '"bladerf_aoa"'
    db_path: db_path
    center_freq: aoa_center
    antenna_spacing_m: antenna_spacing_m
    cal_active: cal_on
    cal_file: '"aoa_cal.json"'
    invert: 'False'
    debug: 'False'
  states: {}
- name: aoa_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: aoa_samp_rate
    comment: RX0 — see ch37 traffic + the calibration reference when present
    fc: aoa_center
    fftsize: '4096'
    name: '"AoA RX0 (ch37)"'
    type: complex
  states: {}
- name: phase_num
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    comment: raw inter-channel phase (rad), before phi_cal subtraction
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: raw dphi (rad)
    max: '3.2'
    min: '-3.2'
    type: float
    unit1: rad
  states: {}

connections:
- [aoa_source, '0', ref_gfsk, '0']
- [aoa_source, '0', ref_mag2, '0']
- [aoa_source, '0', aoa_waterfall, '0']
- [aoa_source, '0', cross, '0']
- [aoa_source, '1', cross, '1']
- [ref_gfsk, '0', aoa_decoder, '0']
- [ref_mag2, '0', ref_keep, '0']
- [ref_keep, '0', aoa_decoder, '1']
- [cross, '0', cross_keep, '0']
- [cross_keep, '0', aoa_decoder, '2']
- [cross_keep, '0', cross_arg, '0']
- [cross_arg, '0', phase_num, '0']

metadata:
  file_format: 1
