options:
  parameters:
    description: 'bladeRF half of the dual capture: covers ch37+38 via two xlating filters at +/-12 MHz from 2.414 GHz center. Runs as its own process (paired with ble_pluto.grc) to dodge libusb in-process serialization. Logs to the shared sqlite db.'
    generate_options: qt_gui
    id: ble_blade
    output_language: python
    title: BLE capture (bladeRF ch37/38)
  states: {}

blocks:
- name: db_path
  id: variable
  parameters:
    value: '"ble_scan.db"'
  states: {}
- name: blade_samp_rate
  id: variable
  parameters:
    value: '28000000'
  states: {}
- name: blade_center
  id: variable
  parameters:
    comment: midpoint of ch37/ch38
    value: 2.414e9
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '24000000'
    center_freq: blade_center
    comment: fc32 (complex) mode — proven path that hits 28 MSPS without underrun
    dev_args: buflen=32768,buffers=128
    gain: '40.0'
    samp_rate: blade_samp_rate
    type: complex
  states: {}
- name: blade_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: blade_samp_rate
    comment: bladeRF wideband view (ch37+38)
    fc: blade_center
    fftsize: '4096'
    name: '"bladeRF"'
    type: complex
  states: {}
- name: blade_ch37_xlate
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-12e6'
    comment: extract ch37 (2402 MHz)
    decim: '7'
    samp_rate: blade_samp_rate
    taps: firdes.low_pass(1.0, blade_samp_rate, 1_000_000, 250_000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: blade_ch37_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blade_ch37_keep1n
  id: blocks_keep_one_in_n
  parameters:
    comment: 4 MSPS -> 1 MSPS
    n: '4'
    type: float
  states: {}
- name: blade_ch37_gfsk
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: blade_ch37_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Shim: thin GRC wrapper around ble_decoder_sqlite.blk."""
      import os, sys
      _HERE = os.path.expanduser('~/Software/rf-parts/simple-plutoble-scanner')
      if _HERE not in sys.path:
          sys.path.insert(0, _HERE)
      from ble_decoder_sqlite import blk as _Parent


      class blk(_Parent):
          def __init__(self, channel_index=37, sdr_name="bladerf",
                       db_path="ble_scan.db", invert=False, debug=False):
              _Parent.__init__(self, channel_index=channel_index,
                               sdr_name=sdr_name, db_path=db_path,
                               invert=invert, debug=debug)
    channel_index: '37'
    sdr_name: '"bladerf"'
    db_path: db_path
    invert: 'False'
    debug: 'False'
  states: {}
- name: blade_ch38_xlate
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 12e6
    comment: extract ch38 (2426 MHz)
    decim: '7'
    samp_rate: blade_samp_rate
    taps: firdes.low_pass(1.0, blade_samp_rate, 1_000_000, 250_000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: blade_ch38_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blade_ch38_keep1n
  id: blocks_keep_one_in_n
  parameters:
    comment: 4 MSPS -> 1 MSPS
    n: '4'
    type: float
  states: {}
- name: blade_ch38_gfsk
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: blade_ch38_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Shim: thin GRC wrapper around ble_decoder_sqlite.blk."""
      import os, sys
      _HERE = os.path.expanduser('~/Software/rf-parts/simple-plutoble-scanner')
      if _HERE not in sys.path:
          sys.path.insert(0, _HERE)
      from ble_decoder_sqlite import blk as _Parent


      class blk(_Parent):
          def __init__(self, channel_index=38, sdr_name="bladerf",
                       db_path="ble_scan.db", invert=False, debug=False):
              _Parent.__init__(self, channel_index=channel_index,
                               sdr_name=sdr_name, db_path=db_path,
                               invert=invert, debug=debug)
    channel_index: '38'
    sdr_name: '"bladerf"'
    db_path: db_path
    invert: 'False'
    debug: 'False'
  states: {}

connections:
- [soapy_bladerf_source_0, '0', blade_waterfall, '0']
- [soapy_bladerf_source_0, '0', blade_ch37_xlate, '0']
- [soapy_bladerf_source_0, '0', blade_ch38_xlate, '0']
- [blade_ch37_xlate, '0', blade_ch37_mag2, '0']
- [blade_ch37_xlate, '0', blade_ch37_gfsk, '0']
- [blade_ch37_mag2, '0', blade_ch37_keep1n, '0']
- [blade_ch37_keep1n, '0', blade_ch37_decoder, '1']
- [blade_ch37_gfsk, '0', blade_ch37_decoder, '0']
- [blade_ch38_xlate, '0', blade_ch38_mag2, '0']
- [blade_ch38_xlate, '0', blade_ch38_gfsk, '0']
- [blade_ch38_mag2, '0', blade_ch38_keep1n, '0']
- [blade_ch38_keep1n, '0', blade_ch38_decoder, '1']
- [blade_ch38_gfsk, '0', blade_ch38_decoder, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
