options:
  parameters:
    comment: |-
      PlutoSDR XO calibration helper.
      Tune to a known reference (e.g. WiFi beacon center 2412e6 for ch 1, or 2402e6 + run ble_advertise). Observe the spike location vs the 0 Hz center line. Use the offset_hz slider to align the cursor mentally, read off offset, convert to ppm with the formula:
      ppm = offset_hz / tune_center * 1e6 xo_correction_hz = 40_000_000 - 40_000_000 * (ppm / 1e6)
      Apply once permanently in /Volumes/PlutoSDR/config.txt under [SYSTEM]: xo_correction = <integer Hz of XO frequency>
    description: XO calibration via visual peak alignment
    generate_options: qt_gui
    id: tune
    output_language: python
    title: PlutoSDR XO Tuning
  states: {}

blocks:
- name: offset_hz
  id: variable_qtgui_range
  parameters:
    comment: Cancel out the observed offset; read final value as XO drift
    label: Software offset (Hz)
    start: '-200000'
    step: '10'
    stop: '200000'
    value: '0'
  states: {}
- name: ppm_label
  id: variable_qtgui_label
  parameters:
    comment: Live ppm reading
    formatter: 'lambda v: f"{v * 1e6 / tune_center:+.3f} ppm"'
    label: XO offset
    type: real
    value: offset_hz
  states: {}
- name: rf_bw
  id: variable
  parameters:
    comment: Pluto boot RF bandwidth — DO NOT change (rewrite crashes firmware)
    value: '18000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Pluto boot rate — DO NOT CHANGE
    value: '30720000'
  states: {}
- name: tune_center
  id: variable
  parameters:
    comment: Must equal Pluto boot LO (2400000000) — retune crashes firmware. Default 2.4 GHz window covers BLE ch37 (2402, +2 MHz offset) and WiFi ch1 center (2412, +12 MHz offset).
    value: '2402000000'
  states: {}
- name: xo_correction_hint
  id: variable_qtgui_label
  parameters:
    comment: XO frequency to write into config.txt
    formatter: 'lambda v: f"xo_correction = {int(40000000 - 40000000 * (v / tune_center)):d}"'
    label: config.txt value
    type: real
    value: offset_hz
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: 'Adds offset_hz of frequency offset (software-only). Use to virtually shift the spectrum: drag slider until your known reference signal sits at 0 Hz.'
    phase_inc: '-2*math.pi * offset_hz / samp_rate'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'False'
    bandwidth: rf_bw
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(tune_center)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Peak-hold ON, avg 0.1 — easy to spot intermittent signals. Cursor in plot reads off frequency to ~10 Hz resolution.
    ctrlpanel: 'True'
    fc: tune_center
    fftsize: '32768'
    freqhalf: 'False'
    grid: 'True'
    label: Spectrum
    legend: 'False'
    type: complex
    update_time: '0.05'
    ymax: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tune_center
    fftsize: '4096'
    freqhalf: 'False'
    int_max: '-40'
    int_min: '-120'
    type: complex
  states: {}

connections:
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
