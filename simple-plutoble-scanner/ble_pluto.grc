options:
  parameters:
    description: 'Pluto half of the dual capture: covers ch39 (2.480 GHz) at 4 MSPS direct. Runs as its own process (paired with ble_blade.grc) to dodge libusb in-process serialization. Logs to the shared sqlite db.'
    generate_options: qt_gui
    id: ble_pluto
    output_language: python
    title: BLE capture (Pluto ch39)
  states: {}

blocks:
- name: db_path
  id: variable
  parameters:
    value: '"ble_scan.db"'
  states: {}
- name: pluto_samp_rate
  id: variable
  parameters:
    comment: low rate — avoids USB contention with bladeRF
    value: '4000000'
  states: {}
- name: pluto_rf_bw
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: pluto_center
  id: variable
  parameters:
    comment: ch39 = 2480 MHz
    value: 2.480e9
  states: {}
- name: iio_pluto_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: pluto_rf_bw
    center_freq: pluto_center
    comment: 'NOTE: the GRC plutosdr block hardcodes dev=driver=plutosdr (no URI). The runner script (run.sh) sed-patches the generated .py to inject uri=usb:0.3.5. Do not run the .py directly — use run.sh.'
    freq_correction: '0'
    gain: '30.0'
    samp_rate: pluto_samp_rate
    type: complex
  states: {}
- name: pluto_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: pluto_samp_rate
    comment: Pluto (ch39)
    fc: pluto_center
    fftsize: '4096'
    name: '"Pluto ch39"'
    type: complex
  states: {}
- name: pluto_ch39_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: pluto_ch39_keep1n
  id: blocks_keep_one_in_n
  parameters:
    comment: 4 MSPS -> 1 MSPS
    n: '4'
    type: float
  states: {}
- name: pluto_ch39_gfsk
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: pluto_ch39_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Shim: thin GRC wrapper around ble_decoder_sqlite.blk."""
      import os, sys
      _HERE = os.path.expanduser('~/Software/rf-parts/simple-plutoble-scanner')
      if _HERE not in sys.path:
          sys.path.insert(0, _HERE)
      from ble_decoder_sqlite import blk as _Parent


      class blk(_Parent):
          def __init__(self, channel_index=39, sdr_name="pluto",
                       db_path="ble_scan.db", invert=False, debug=False):
              _Parent.__init__(self, channel_index=channel_index,
                               sdr_name=sdr_name, db_path=db_path,
                               invert=invert, debug=debug)
    channel_index: '39'
    sdr_name: '"pluto"'
    db_path: db_path
    invert: 'False'
    debug: 'False'
  states: {}

connections:
- [iio_pluto_source_0, '0', pluto_waterfall, '0']
- [iio_pluto_source_0, '0', pluto_ch39_mag2, '0']
- [iio_pluto_source_0, '0', pluto_ch39_gfsk, '0']
- [pluto_ch39_mag2, '0', pluto_ch39_keep1n, '0']
- [pluto_ch39_keep1n, '0', pluto_ch39_decoder, '1']
- [pluto_ch39_gfsk, '0', pluto_ch39_decoder, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
